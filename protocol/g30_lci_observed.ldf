LIN_description_file;
LIN_protocol_version = "2.2";
LIN_language_version = "2.2";
LIN_speed = 19.2 kbps;

Nodes {
  Master: LAB_UNVERIFIED, 5 ms, 0.1 ms;
  Slaves: ;
}

Signals { }
Frames { }
Schedule_tables { }
